# Keil uVision project Project.uvprojx, settings and files
target GD32F4XX (5040049::V5.04 update 1 (build 49)::.\ARMCC)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\..\Firmware\CMSIS\GD\GD32F4xx\Include;..\..\Utilities;..\..\Firmware\CMSIS;..\..\Template;..\..\Firmware\CMSIS\GD\GD32F4xx\Source\ARM;..\..\Firmware\GD32F4xx_standard_peripheral\Include;..\..\HardWare
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: gd32f4xx_it.c main.c systick.c function.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Peripherals
    ../../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rtc.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_gpio.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_rcu.c gd32f4xx_trng.c gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Doc
    ../: readme.txt
  group HardWare
    ../../HardWare/: LED.c BEEP.c KEY.c USART0.c ZigBee_UART3.c MultiTimer.c Timer.c UART4_Lcd.c ESP8266.c IrDA.c ESP32_CAM.c
software components: CMSIS:CORE 5.6.0
